# Keil uVision project Demo.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F051C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F051
  c include: .\App;.\Bsp;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f051.s
  group STM32F0xx_StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c
  group CMSIS
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f0xx.c
  group FreeRTOS/Ports
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM0/: port.c portmacro.h
  group FreeRTOS/Source
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Bsp
    ./Bsp/: bsp.c
  group App
    ./App/: main.c app_task.c stm32f0xx_it.c FreeRTOSConfig.h
  group Doc
    ./Doc/: ReadMe.txt
